PACKAGECONFIG:append = "gles2"
PACKAGECONFIG:append = "sql-sqlite"
